CMDLINE_SERIAL = "console=ttyAMA0,115200"


CMDLINE:append = " loglevel=7 rw"
